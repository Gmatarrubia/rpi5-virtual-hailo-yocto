RDEPENDS:${PN}:append = " python3-shell"
