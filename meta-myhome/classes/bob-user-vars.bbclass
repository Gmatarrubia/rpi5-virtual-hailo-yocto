
# Common variables
BOB_USER_NAME = "bob"
BOB_USER_PATH = "/home/${BOB_USER_NAME}"
BOB_USER_PASSWORD = '\$6\$UvQ3WDtWnffeC1QD\$ovTT2hl.0rc2wDi4re2kcRGDBUG.XjSyYIuY85lnFjJeKcn1CA9eYdNjhoeOWMqIwNUy8i3QOwjGbmT2SVwre1'
