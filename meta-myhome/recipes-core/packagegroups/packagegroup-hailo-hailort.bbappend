RDEPENDS:${PN}-base:remove = "hailort-server"
