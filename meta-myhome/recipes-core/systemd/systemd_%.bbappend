PACKAGECONFIG:append = " networkd resolved"
PACKAGECONFIG:remove = "osc-context"
